FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

EXTRA_OECMAKE += "-DJSONCPP_LIB_BUILD_SHARED=ON \
		  -DJSONCPP_WITH_PKGCONFIG_SUPPORT=ON \
		  "

BBCLASSEXTEND = "native"
