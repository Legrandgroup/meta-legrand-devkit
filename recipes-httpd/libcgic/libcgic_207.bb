require libcgic.inc

SRC_URI += " file://libcgic-207-fix-makefile-use-CC-variable.patch"

SRC_URI[md5sum] = "25ef17e2f4f1f4a6a054f0a5dab6e463"
SRC_URI[sha256sum] = "1e8834642a4b89528bb7bde2f287e133c6b07e210e68681a34137c436d59d320"
