require smarty.inc

S = "${WORKDIR}/Smarty-${PV}"

SRC_URI += "http://www.smarty.net/files/Smarty-${PV}.tar.gz"

SRC_URI[md5sum] = "8db6f31fcf80aa0e0cbb064112fbb1bd"
SRC_URI[sha256sum] = "445b583853774ebd17685abade5e3e76a0f3422dea2191611fb308faec276574"
